# Keil uVision project RTC_lib.uvproj, settings and files
target RTC_lib (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTC_lib +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\App;..\Header\CMSIS_CM3_CoreSupport;..\Header\CMSIS_CM3_DeviceSupport_ST_STM32F10x;..\Header\inc_STM32F10x_StdPeriph_Driver;..\Header\Utilities_STM32_EVAL;..\Header\Utilities_STM32_EVAL\STM3210B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../App/: main.c stm32f10x_it.c system_stm32f10x.c
  group LIB
    ../Lib/: STM32_LIB_MD.lib
