# Keil uVision project IWDG.uvproj, settings and files
target Z32R (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IWDG +hex
  c flags: Optim=1
  c include: .\Initialisation;.\Drivers
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Initialisation
    ./Initialisation/: STM32F10x.s STM32_Init.c
  group Drivers
    ./Drivers/: TFT018.c
  group Application
    ./Application/: IWDG.c
