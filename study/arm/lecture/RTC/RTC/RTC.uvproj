# Keil uVision project RTC.uvproj, settings and files
target RTC (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTC +hex
  c flags: Optim=1
  c include: .\Initialisation;.\Drivers;.\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Initialisation
    ./Initialisation/: STM32F10x.s STM32_Init.c
  group Application
    ./Application/: RTC.c
