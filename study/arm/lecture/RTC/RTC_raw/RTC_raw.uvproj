# Keil uVision project RTC_raw.uvproj, settings and files
target RTC_raw (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTC_raw +hex
  c flags: Optim=1
  c include: .\Initialisation;.\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Initialisation
    ./Initialisation/: STM32_Init.c STM32F10x.s
  group Application
    ./Application/: Retarget.c rtc_raw.c
  group Lib
    C:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB
