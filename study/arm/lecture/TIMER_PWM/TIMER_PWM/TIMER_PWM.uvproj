# Keil uVision project TIMER_PWM.uvproj, settings and files
target TIMER_PWM (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TIMER_PWM +hex
  c flags: Optim=1
  c include: .\Initialisation;.\Drivers;.\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Initialisation
    ./Initialisation/: STM32F10x.s STM32_Init.c
  group Application
    ./Application/: Timer_pwm.c
