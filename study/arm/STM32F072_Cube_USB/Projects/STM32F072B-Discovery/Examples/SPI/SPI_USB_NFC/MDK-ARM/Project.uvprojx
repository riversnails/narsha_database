# Keil uVision project Project.uvprojx, settings and files
target STM32F072B-Discovery (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F072B-Discovery +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F072B_DISCO
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F072B-Discovery;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_spi.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_ll_usb.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c pn532.c pn532_stm32f1.c usbd_conf.c usbd_desc.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Drivers/BSP/STM32F072B-Discovery
    ../../../../../../Drivers/BSP/STM32F072B-Discovery/: stm32f072b_discovery.c
software components: CMSIS:CORE 4.1.0
