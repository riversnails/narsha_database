# Keil uVision project IOToggle.uvproj, settings and files
target IOToggle (ARM-ADS)
  device: STM32F207VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: IOToggle +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\STM32F2xx_StdPeriph_Examples\GPIO\IOToggle;..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../../../STM32F2xx_StdPeriph_Examples/GPIO/IOToggle/: main.c stm32f2xx_it.c system_stm32f2xx.c
  group StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c
