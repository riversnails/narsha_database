# Keil uVision project Project.uvproj, settings and files
target STM322xG_EVAL (ARM-ADS)
  device: STM32F207VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../../STM32F2xx_StdPeriph_Examples/SysTick/SysTick_Example/: main.c stm32f2xx_it.c system_stm32f2xx.c
