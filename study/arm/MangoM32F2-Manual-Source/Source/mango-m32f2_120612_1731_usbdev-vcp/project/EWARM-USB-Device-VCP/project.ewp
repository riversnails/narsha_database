# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VG ST STM32F207VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USB_TEST
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\src; ..\..\src\USB-Device-VCP\inc; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Library
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_exti.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_usart.c
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group src
    ../../src/USB-Device-VCP/src/: app.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    ../../src/: hw_config.c main.c stm32f2xx_it.c test.c
  group USB Device/Class/CDC
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB Device/Library
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Drivers
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
