# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VG ST STM32F207VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pe177
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Libraries\STM32F2x7_ETH_Driver\inc; ..\..\src; ..\..\src\httpserver\inc; ..\..\Third_Party\lwip_v1.3.2\src\include\; ..\..\Third_Party\lwip_v1.3.2\src\include\lwip; ..\..\Third_Party\lwip_v1.3.2\src\include\netif; ..\..\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\Third_Party\lwip_v1.3.2\port\STM32F2x7; ..\..\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Library
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_exti.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_usart.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/iar/: startup_stm32f2xx.s
    ../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group lwIP/api
    ../../Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP/core
    ../../Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwIP/core/ipv4
    ../../Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwIP/netif
    ../../Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../Third_Party/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group src
    ../../src/httpserver/src/: fs.c httpd.c httpd_cgi_ssi.c httpserver_test.c netconf.c stm32f2x7_eth_bsp.c
    ../../src/: hw_config.c main.c stm32f2xx_it.c test.c
