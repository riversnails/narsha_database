# Keil uVision project ADC1_DMA_LIB.uvproj, settings and files
target ADC1_DMA_LIB (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ADC1_DMA_LIB +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\ADC1_DMA_LIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group LIB
    G:/data/STM32F10x_StdPeriph_Lib_V3.5.0/keil/ADC/ADC1_DMA_LIB/: STM32_LIB.lib
